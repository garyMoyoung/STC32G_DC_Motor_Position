# Keil uVision project STC32G_Test_06_SPI通信OLED屏.uvproj, settings and files
target Target 1 (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: STC32G_Test_06_SPI通信OLED屏 +hex
  group Source Group 1
    ./: main.c oled.c spi.c uart.c uart.h timer.c timer.h main.h
